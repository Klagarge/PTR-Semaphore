# Keil uVision project lab03-semaphore.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: lab01-rtx5
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Hesso pack:Extension Board:LEDs 1.0.0, Hesso pack:Extension Board:UART 1.0.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:PWR 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:UART 1.2.7, Device:Startup 1.2.4
